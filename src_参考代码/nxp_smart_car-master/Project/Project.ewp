# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\Drive; src\Lib\Libs; src\Lib\Linker; src\Lib\Startup; src\App
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\Phantom\src\Lib\Linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xX1M_18.icf
  group App
    src/App/: include.h main.c user_common.h
  group App/ccd
    src/App/: ccd.c ccd.h
  group App/electromagnetics
    src/App/: electromagnetics.c electromagnetics.h
  group App/func
    src/App/: func.c func.h
  group App/ICM20602
    src/App/: ICM20602.c ICM20602.h
  group App/image
    src/App/: ImageRecognition.c ImageRecognition.h
  group App/init
    src/App/: init.c init.h
  group App/irq
    src/App/: IRQ_Handler.c
  group App/motor
    src/App/: motor.c motor.h
  group App/screen/12864
    src/App/: 12864.c 12864.h
  group Driver
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SPI.c MK60_SPI.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Lib/startup
    src/Lib/Libs/: MK66F18.h
    src/Lib/Startup/: start.c startup_MK66F18.s
