# Keil uVision project LQSTCdemo.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LQdemo +hex
  link misc: REMOVEUNUSED
  group MAIN
    ./: main.c 读我读我.txt
  group APP
    ./user/: include.h LQ_ADC.c LQ_ADC.h LQ_GPIO_EXIT.c LQ_GPIO_EXIT.h LQ_GPIO_KEY.c LQ_GPIO_KEY.h LQ_GPIO_LED.c LQ_GPIO_LED.h LQ_I2C.c LQ_I2C.h LQ_OLED096.c LQ_OLED096.h LQ_SPI.c LQ_SPI.h LQ_TIMER.c LQ_TIMER.h LQ_SOFTI2C.h LQ_ICM20689.c LQ_ICM20689.h LQ_MotorServo.c LQ_MotorServo.h LQ_Encoder.c LQ_Encoder.h LQ_UART.c LQ_UART.h ANO_DT.c ANO_DT.h STC16F.h LQ_SOFTI2C.c LQ_PID.c LQ_PID.h
  group dianci
    ./user/Dianci/: LQ_dianci.c LQ_dianci.h
